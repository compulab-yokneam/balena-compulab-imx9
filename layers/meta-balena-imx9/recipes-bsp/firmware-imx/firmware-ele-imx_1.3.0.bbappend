# add the following until we update to a meta-freescale version that has this license added to fsl-eula-unpack.bbclass
LIC_FILES_CHKSUM = "file://COPYING;md5=a93b654673e1bc8398ed1f30e0813359"
unset do_populate_lic[noexec]
